options:
  parameters:
    author: K&S
    generate_options: qt_gui
    id: ModuladorAM
    output_language: python
    title: MODULADORAM
  states: {}

blocks:
- name: A
  id: variable_qtgui_range
  parameters:
    label: Amplitud mensaje
    start: '0'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: Ac
  id: variable_qtgui_range
  parameters:
    label: Amplitud portadora
    start: '0'
    step: '0.01'
    stop: '4'
    value: '0.1'
  states: {}
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia TX
    start: '0'
    step: '1'
    stop: '31'
    value: '0'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora
    start: '50'
    step: '0.1'
    stop: '2200'
    value: '50'
  states: {}
- name: ka
  id: variable_qtgui_range
  parameters:
    label: coeficiente ka
    start: '0'
    step: '0.01'
    stop: '4'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: BloqueModuladorAM_0
  id: BloqueModuladorAM
  parameters:
    Ac: Ac
    ka: ka
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '20000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc*1000000
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [BloqueModuladorAM_0, '0', qtgui_freq_sink_x_0, '0']
- [BloqueModuladorAM_0, '0', qtgui_time_sink_x_0, '0']
- [BloqueModuladorAM_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0, '0', BloqueModuladorAM_0, '0']

metadata:
  file_format: 1
